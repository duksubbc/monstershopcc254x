# IAR project HIDAdvRemote.ewp, settings and files
configuration CC2541 AdvRemote (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; POWER_SAVING; CELL_BATTERY; HCI_DISABLE_UART; xDEBUG; HCI_SINGLE_CHIP; GAP_PRIVACY_RECONNECT; TEST_MODE; HCI_DISABLE_PTM; HAL_BUZZER=TRUE; HAL_KEY=TRUE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_MOTION=TRUE; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_BATMON=TRUE; HAL_ADC=TRUE; HAL_TIMER=FALSE; HAL_UART=FALSE; HAL_I2C=TRUE; XOSC32K_INSTALLED=TRUE; GAP_CHAR_CFG_MAX=8; HAL_I2C_MASTER=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\hal\target\CC2541ARC; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\HidDevKbM\CC254x; ..\..\Profiles\HidDevKbM; ..\..\Profiles\HidDev\CC254x; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt\CC254x; ..\..\Profiles\ScanParam\CC254x; ..\..\Profiles\ScanParam
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: hidAdvRemote.c hidAdvRemote.h hidAdvRemote_main.c OSAL_hidAdvRemote.c
  group HAL/Common
    ../../../../Components/hal/target/CC2541ARC/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/hal/target/CC2541ARC/: hal_drivers.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2541ARC/: hal_accel.c hal_accel.h hal_buzzer.c hal_buzzer.h hal_gyro.c hal_gyro.h hal_i2c.c hal_i2c.h hal_key.c hal_motion.c hal_motion.h hal_sleep.c
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_led.c hal_startup.c hal_uart.c
  group HAL/Target/CC2540EB/Drivers/LIB
    ../../../../Components/hal/target/CC2541ARC/: AIR_MOTION_LIB_3G3A-Banked.r51
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/CC254x/include/: ll.h phy.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Batt/CC254x/: battservice.c battservice.h
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/HIDDev/CC254x/: hiddev.c hiddev.h
    ../../Profiles/HIDDevKbM/CC254x/: hidkbmservice.c
    ../../Profiles/HIDDevKbM/: hidkbmservice.h
    ../../Profiles/Roles/CC254x/: peripheral.c peripheral.h
    ../../Profiles/ScanParam/CC254x/: scanparamservice.c
    ../../Profiles/ScanParam/: scanparamservice.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: lnk51ew_cc2530b_banked_rom_data.xcl lnk_banked_rom_data.xcl OnBoard.c OnBoard.h
